File: 2026_C_AV_PC_V1/2026_C_AV_PC_V1.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: spine almost finished
Other:
- note added: "Propultion Computer (PRC)"
